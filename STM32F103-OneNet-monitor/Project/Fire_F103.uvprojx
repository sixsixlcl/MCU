# Keil uVision project Fire_F103.uvprojx, settings and files
target HAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Fire_F103 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --no_multibyte_chars
  c include: ..\Libraries\CMSIS\Device\ST\STM32F1xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F1xx_HAL_Driver\Inc;..\User;..\APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group STM32F1xx_HAL_Driver
    ../Libraries/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_dma.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_i2c.c
  group USER
    ../User/: main.c stm32f1xx_it.c
    ../User/dwt/: bsp_dwt.c
    ../User/led/: bsp_led.c
    ../User/alarm/: bsp_alarm.c
  group APP
    ../User/dht11/: bsp_dht11.c
    ../User/: MqttKit.c cJSON.c bsp_delay.c onenet.c esp8266.c
    ../User/fonts/: bsp_fonts.c
    ../APP/dht11_oled/: app_dht11_oled.c
    ../User/oled/: bsp_i2c_oled.c
    ../User/i2c/: bsp_i2c.c
    ../User/usart/: bsp_usart.c
  group DOC
    ../Doc/: readme.txt
